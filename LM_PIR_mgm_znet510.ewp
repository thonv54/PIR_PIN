# IAR project LM_PIR_mgm_znet510.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P132F256GM48 SiliconLaboratories EFR32MG1P132F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NULL_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; PHY_RAIL; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510_endpoint_config.h"; BOARD_HEADER="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4153A; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; HAL_CONFIG="app/hal-config/zigbee-config.h"; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/LM_PIR_mgm_znet510/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/LM_PIR_mgm_znet510/afv2-mfg-token.h"; HAL_ANTDIV_ENABLE=0; HAL_PTA_ENABLE=0; HAL_RHO_ENABLE=0; HAL_SERIAL_RXWAKE_ENABLE=0; HAL_SERIAL_VCOM_ENABLE=1; HAL_SERIAL_VUART_ENABLE=0; HAL_WDOG_ENABLE=1; HAL_SERIAL_LEUART0_ENABLE=0; HAL_LEUART0_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_LEUART1_ENABLE=0; HAL_LEUART1_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_USART0_ENABLE=1; HAL_USART0_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_HW; HAL_SERIAL_USART1_ENABLE=0; HAL_USART1_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_USART2_ENABLE=0; HAL_USART2_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_USART3_ENABLE=0; HAL_USART3_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; BSP_UARTNCP_USART_PORT=HAL_SERIAL_PORT_USART0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.10\app\framework; ..\..\..\protocol\zigbee_5.10\app\framework\..\..; ..\..\..\protocol\zigbee_5.10\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.10\app\framework\..\util; ..\..\..\protocol\zigbee_5.10\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg1p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\EFR32MG1_BRD4153A\config; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4153A\config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_RAIL; EFR32_SERIES1_CONFIG1_MICRO; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510_endpoint_config.h"; BOARD_HEADER="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/LM_PIR_mgm_znet510/LM_PIR_mgm_znet510.h"; BOARD_BRD4153A; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; HAL_CONFIG="app/hal-config/zigbee-config.h"; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/LM_PIR_mgm_znet510/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/LM_PIR_mgm_znet510/afv2-mfg-token.h"; HAL_ANTDIV_ENABLE=0; HAL_PTA_ENABLE=0; HAL_RHO_ENABLE=0; HAL_SERIAL_RXWAKE_ENABLE=0; HAL_SERIAL_VCOM_ENABLE=1; HAL_SERIAL_VUART_ENABLE=0; HAL_WDOG_ENABLE=1; HAL_SERIAL_LEUART0_ENABLE=0; HAL_LEUART0_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_LEUART1_ENABLE=0; HAL_LEUART1_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_USART0_ENABLE=1; HAL_USART0_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_HW; HAL_SERIAL_USART1_ENABLE=0; HAL_USART1_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_USART2_ENABLE=0; HAL_USART2_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; HAL_SERIAL_USART3_ENABLE=0; HAL_USART3_FLOW_CONTROL=HAL_USART_FLOW_CONTROL_NONE; BSP_UARTNCP_USART_PORT=HAL_SERIAL_PORT_USART0
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.10\app\framework; ..\..\..\protocol\zigbee_5.10\app\framework\..\..; ..\..\..\protocol\zigbee_5.10\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.10\app\framework\..\util; ..\..\..\protocol\zigbee_5.10\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg1p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\EFR32MG1_BRD4153A\config; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4153A\config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  OBJCOPY.OOCOutputFile: LM_PIR_mgm_znet510.s37
  postbuild: LM_PIR_mgm_znet510-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$'
  ILINK.IlinkOutputFile: LM_PIR_mgm_znet510.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=262144; RAM_SIZE=32768; NULL_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../app/builder/LM_PIR_mgm_znet510/: LM_PIR_mgm_znet510_callbacks.c
    ../../../platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/address-table/: address-table.c address-table-cli.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/end-device-support/: end-device-support.c end-device-move.c end-device-support-cli.c polling-common.c polling-soc.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../protocol/zigbee_5.10/app/util/common/: form-and-join.c form-and-join-node-adapter.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/network-find/: network-find.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/reporting/: reporting.c reporting-cli.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../../protocol/zigbee_5.10/app/framework/plugin/simple-main/: simple-main.c
    ../../../protocol/zigbee_5.10/app/framework/plugin-soc/idle-sleep/: idle-sleep.c idle-sleep-cli.c idle-sleep-soc.c
    ../../../platform/base/hal/plugin/adc/: adc-efr32.c
    ../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../../../platform/base/hal/plugin/debug-jtag/: debug-jtag-efr32.c
    ../../../platform/base/hal/micro/cortexm3/efm32/: hal-config.c hal-config-gpio.c assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c ext-device.c
    ../../../platform/base/hal/plugin/coexistence/: coexistence-efr32.c
    ../../../platform/base/hal/plugin/sim-eeprom1/: sim-eeprom.c
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../protocol/zigbee_5.10/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../../protocol/zigbee_5.10/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ../../../protocol/zigbee_5.10/app/framework/../util/serial/: command-interpreter2.c
    ../../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../../protocol/zigbee_5.10/app/framework/../../stack/config/: ember-configuration.c
    ../../../protocol/zigbee_5.10/app/framework/../util/common/: library.c
    ../../../protocol/zigbee_5.10/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../protocol/zigbee_5.10/app/framework/../util/security/: security-address-cache.c
    ../../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../platform/base/hal/: ember-base-configuration.c
    ../../../protocol/zigbee_5.10/app/framework/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../../platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../platform/base/hal/../../emdrv/spidrv/src/: spidrv.c
    ../../../platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../platform/base/hal/../../emdrv/uartdrv/src/: uartdrv.c
    ../../../platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../platform/base/hal/../../Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
  group Libraries
    ../../../protocol/zigbee_5.10/build/binding-table-library-cortexm3-iar-efr32mg1p-rail/: binding-table-library.a
    ../../../protocol/zigbee_5.10/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-163k1-stub-library.a
    ../../../protocol/zigbee_5.10/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-283k1-stub-library.a
    ../../../protocol/zigbee_5.10/build/cbke-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-stub-library.a
    ../../../protocol/zigbee_5.10/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-sign-stub.a
    ../../../protocol/zigbee_5.10/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-verify-stub.a
    ../../../protocol/zigbee_5.10/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../protocol/zigbee_5.10/build/debug-basic-library-cortexm3-iar-efr32mg1p-rail/: debug-basic-library.a
    ../../../protocol/zigbee_5.10/build/debug-extended-stub-library-cortexm3-iar-efr32mg1p-rail/: debug-extended-stub-library.a
    ../../../protocol/zigbee_5.10/build/end-device-bind-stub-library-cortexm3-iar-efr32mg1p-rail/: end-device-bind-stub-library.a
    ../../../protocol/zigbee_5.10/build/enhanced-beacon-request-stub-library-cortexm3-iar-efr32mg1p-rail/: enhanced-beacon-request-stub-library.a
    ../../../protocol/zigbee_5.10/build/gp-stub-library-cortexm3-iar-efr32mg1p-rail/: gp-stub-library.a
    ../../../protocol/zigbee_5.10/build/install-code-library-stub-cortexm3-iar-efr32mg1p-rail/: install-code-library-stub.a
    ../../../protocol/zigbee_5.10/build/multi-network-stub-library-cortexm3-iar-efr32mg1p-rail/: multi-network-stub-library.a
    ../../../protocol/zigbee_5.10/build/packet-validate-library-cortexm3-iar-efr32mg1p-rail/: packet-validate-library.a
    ../../../protocol/zigbee_5.10/build/rf4ce-stack-stub-library-cortexm3-iar-efr32mg1p-rail/: rf4ce-stack-stub-library.a
    ../../../protocol/zigbee_5.10/build/security-library-core-cortexm3-iar-efr32mg1p-rail/: security-library-core.a
    ../../../protocol/zigbee_5.10/build/security-library-link-keys-stub-cortexm3-iar-efr32mg1p-rail/: security-library-link-keys-stub.a
    ../../../protocol/zigbee_5.10/build/zigbee-pro-stack-cortexm3-iar-efr32mg1p-rail/: zigbee-pro-stack.a
    ../../../protocol/zigbee_5.10/build/zll-stub-library-cortexm3-iar-efr32mg1p-rail/: zll-stub-library.a
    ../../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg1_iar_release.a
    ../../../protocol/zigbee_5.10/build/hal-library-cortexm3-iar-efr32mg1p-rail/: hal-library.a
    ../../../protocol/zigbee_5.10/build/sim-eeprom1-library-cortexm3-iar-efr32mg1p-rail/: sim-eeprom1-library.a
